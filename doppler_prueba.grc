options:
  parameters:
    generate_options: qt_gui
    id: doppler_prueba
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: decimacion
  id: variable
  parameters:
    comment: 91.9e6
    value: '64'
  states: {}
- name: frequency
  id: variable
  parameters:
    comment: 91.9e6
    value: 401.0e6
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '2048000'
  states: {}
- name: blocks_complex_to_interleaved_char_0
  id: blocks_complex_to_interleaved_char
  parameters:
    scale_factor: '1.0'
    vector_output: 'False'
  states: {state: disabled}
- name: blocks_complex_to_interleaved_char_0_0
  id: blocks_complex_to_interleaved_char
  parameters:
    scale_factor: '1.0'
    vector_output: 'False'
  states: {state: disabled}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: C:\Users\nkulvietis\Desktop\10-06-2025-RadarPasivo\Vigilancia_Decimacion2.dat
    type: byte
  states: {state: disabled}
- name: blocks_file_sink_0_0
  id: blocks_file_sink
  parameters:
    file: C:\Users\nkulvietis\Desktop\10-06-2025-RadarPasivo\Referencia_Decimacion2.dat
    type: byte
  states: {state: disabled}
- name: fir_filter_xxx_0
  id: fir_filter_xxx
  parameters:
    decim: decimacion
    taps: '512'
    type: ccc
  states: {}
- name: fir_filter_xxx_0_0
  id: fir_filter_xxx
  parameters:
    decim: decimacion
    taps: '512'
    type: ccc
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    args: '"rtl=0"'
    bb_gain0: '20'
    freq0: frequency
    gain0: '20'
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: osmosdr_source_0_0
  id: osmosdr_source
  parameters:
    args: '"rtl=1"'
    bb_gain0: '20'
    comment: |-
      27
      20
      20
    freq0: frequency
    gain0: '20'
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: qtgui_sink_x_2
  id: qtgui_sink_x
  parameters:
    bw: samp_rate/decimacion
    fc: '0'
    fftsize: '32768'
    name: salida
    rate: '200'
    type: complex
  states: {}
- name: qtgui_sink_x_2_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate/decimacion
    fc: '0'
    fftsize: '32768'
    name: salida2
    rate: '200'
    type: complex
  states: {}

connections:
- [blocks_complex_to_interleaved_char_0, '0', blocks_file_sink_0, '0']
- [blocks_complex_to_interleaved_char_0_0, '0', blocks_file_sink_0_0, '0']
- [fir_filter_xxx_0, '0', blocks_complex_to_interleaved_char_0, '0']
- [fir_filter_xxx_0, '0', qtgui_sink_x_2, '0']
- [fir_filter_xxx_0_0, '0', blocks_complex_to_interleaved_char_0_0, '0']
- [fir_filter_xxx_0_0, '0', qtgui_sink_x_2_0, '0']
- [osmosdr_source_0, '0', fir_filter_xxx_0_0, '0']
- [osmosdr_source_0_0, '0', fir_filter_xxx_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.10.0
